# Keil uVision project Binary-calculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51AC3 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(40000000) MODP2
  output: Binary-calculator
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Binary_calculator.a51
